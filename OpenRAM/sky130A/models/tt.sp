.lib "./sky130.lib.spice" tt
