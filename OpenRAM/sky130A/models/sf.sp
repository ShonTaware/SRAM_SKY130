.lib "./sky130.lib.spice" sf
