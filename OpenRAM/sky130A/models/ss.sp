.lib "./sky130.lib.spice" ss
