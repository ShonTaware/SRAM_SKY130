.lib "./sky130.lib.spice" fs
